require python3-pm-auto-common.inc

SRC_URI = "git://github.com/sunfounder/pm_auto.git;protocol=https;branch=1.2.x"

PV = "1.2.12${SRCPV}"
SRCREV = "dc0c9e368b07f1a83ef41c32a625a0efbccd591a"
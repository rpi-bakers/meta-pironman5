require python3-pm-auto-common.inc

SRC_URI = "git://github.com/sunfounder/pm_auto.git;protocol=https;branch=1.4.x"

PV = "1.4.7${SRCPV}"
SRCREV = "963d2e8a6f8174e042b8fcd590e0cad46d4f4ef5"
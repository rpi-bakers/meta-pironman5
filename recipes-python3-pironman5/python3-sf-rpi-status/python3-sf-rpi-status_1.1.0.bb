require python3-sf-rpi-status-common.inc

PV = "1.1.0${SRCPV}"
SRCREV = "7f7fa9d42f2d62a6b5faf9efc6a01577fc2c38c1"

require python3-sf-rpi-status-common.inc

PV = "1.1.8${SRCPV}"
SRCREV = "06990abf5e72589257c74fe450012e02c253f59f"

require python3-pm-dashboard-common.inc

SRC_URI = "git://github.com/sunfounder/pm_dashboard.git;protocol=https;branch=1.2.x"

PV = "1.2.10${SRCPV}"
SRCREV = "6f9e40eaf742e8ca985b069fc0db9b0c885dacec"
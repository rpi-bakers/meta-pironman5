require python3-pm-dashboard-common.inc

SRC_URI = "git://github.com/sunfounder/pm_dashboard.git;protocol=https;branch=1.4.x"

PV = "1.4.0${SRCPV}"
SRCREV = "1924033f92b861b7a967900148ccc9b38111c696"